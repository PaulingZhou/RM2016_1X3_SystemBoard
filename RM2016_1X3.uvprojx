# Keil uVision project RM2016_1X3.uvprojx, settings and files
target RM2016_1X3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2016_1X3 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_ STM32F4XX, USE_STDPERIPH_DRIVER,
  c include: .\lib\CMSIS\ST\STM32F4xx\Include;.\lib\CMSIS\Include;.\lib\STM32F4xx_StdPeriph_Driver\inc;.\lib\STM32F4-Discovery;.\usr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./lib/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ./lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group Utilities
    ./lib/STM32F4-Discovery/: stm32f4_discovery.c
  group UserCode
    ./usr/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c spi1.c spi1.h mpu9250.c mpu9250.h usart.c usart.h system.c system.h
